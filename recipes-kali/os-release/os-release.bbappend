KALI_IMAGE_TYPE ?= "Kali-oe"

DISTRO_CODENAME = "${KALI_IMAGE_TYPE}"
BUILD_ID ?= "${DATETIME}"
